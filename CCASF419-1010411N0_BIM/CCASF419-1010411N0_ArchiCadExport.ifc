Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-30T09:31:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - Alternate UI 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 09:31:17 2023 * Host: L0310_SARANYUK2 * Database: C:\Users\saranyuk\AppData\Local\Temp\59b96dd1-cee5-4443-ae7b-f284875e56ba\92ccd265-c4a0-4088-b59b-ecba2f94a9b6\ifc * Database version: 5507 * Database creation date: Thu Mar 30 09:31:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 09:31:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 09:31:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_357167
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: CCASF419-1010411N0_REVIT:Acacia SupaSleek Semi Counter Basin 550mm, single hole, CCASF419-1010411N0_REVIT:Acacia SupaSleek Semi Counter Basin 550mm, single hole:357167
In: Level 1
Type - Classification: D2010400 Sinks (Uniformat); Material: Fine Fire Clay, Porcelain - White
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia SupaSleek Semi Counter Basin 550mm, single hole
Material: Porcelain - White
Pset_DistributionFlowElementCommon - Reference: Acacia SupaSleek Semi Counter Basin 550mm, single hole; sets with these values: 2
